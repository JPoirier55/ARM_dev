# Keil uVision project arm2.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.2.0
  cpu: IRAM(0x02000000,0x9000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: arm2
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group Source Group 1
    ./: main.c
    C:/LPCOpen/applications/lpc15xx/startup_code/: keil_startup_lpc15xx.s sysinit.c
  group lib
    C:/LPCOpen/software/lpc_core/lpc_chip/chip_15xx/keil_output/chip_15xx_lib/: chip_15xx_lib.lib
    C:/LPCOpen/software/lpc_core/lpc_board/boards_15xx/nxp_lpcxpresso_1549/keil_output/: board_nxp_lpcxpresso_1549.lib
